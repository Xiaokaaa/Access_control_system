# Keil uVision project 基于RDID的智能门禁系统.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC-STC89
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: 基于RFID的智能门禁系统 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 基于RFID的智能门禁系统.c rc522.c at24c02.c lcd12864.c
